# Keil uVision project TMU3112 HID RW 64BYTES.uvproj, settings and files
target Tenx (MCS-51)
  device: TS80C52X2 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(60000000) MODP2
  output: HID_RW64BYTES.omf +hex
  c flags: Optimize=6 SizeSpeed=1
  group source
    ./: isr.c main.c STARTUP.A51 USBtran.OBJ iic.c iicbridge.c ds2460.c
target TP6806 (MCS-51)
  device: W78E52B Winbond
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) CLOCK(40000000)
  output: tp6806.omf +hex
  c flags: Optimize=6 SizeSpeed=1
